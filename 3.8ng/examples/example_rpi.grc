options:
  parameters:
    generate_options: no_gui
    id: example_rpi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*24
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/N/2
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/N/2
    win: firdes.WIN_HAMMING
  states: {}
- name: acars_acars_0
  id: acars_acars
  parameters:
    filename: /tmp/rtl0
    saveall: 'False'
    threshold: '3'
  states: {}
- name: acars_acars_0_0
  id: acars_acars
  parameters:
    filename: /tmp/rtl+200
    saveall: 'False'
    threshold: '3'
  states: {}
- name: acars_acars_0_0_0
  id: acars_acars
  parameters:
    filename: /tmp/rtl-100
    saveall: 'False'
    threshold: '3'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_am_demod_cf_0_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(24/N)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/N
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '65e-3'
    min_freq: '-65e-3'
    w: '50e-3'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: N
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100000'
    decim: N
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/N/2
    decim: N
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/N/2
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: 131.725e6
    gain0: '49'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', acars_acars_0, '0']
- [analog_am_demod_cf_0_0, '0', acars_acars_0_0_0, '0']
- [analog_am_demod_cf_0_0_0, '0', acars_acars_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_am_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_pll_carriertracking_cc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
